<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimpleUART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SimpleUARTRX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


