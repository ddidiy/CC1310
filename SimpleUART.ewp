# IAR project SimpleUART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1310F128 TexasInstruments CC1310F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$CC13XXWARE$; -Dewarm; --debug; --silent; -Ieasylink; -Ismartrf_settings
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SimpleUART.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC1310DK_7XD.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $CC13XXWARE$/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group RF EasyLink TX/Configuration files
    ./: SimpleUART.cfg
  group RF EasyLink TX/Documentation
    ./: rfEasyLinkTx_readme.txt
  group RF EasyLink TX/Header files
    ./: Board.h CC1310DK_7XD.h
    easylink/: EasyLink.h smartrf_settings_predefined.h
    smartrf_settings/: smartrf_settings.h
  group RF EasyLink TX/Source files
    ./: CC1310DK_7XD.c ccfg.c rfEasyLinkTx.c SimpleUART_CC1310DK_7XD.icf
    easylink/: EasyLink.c smartrf_settings_predefined.c
    smartrf_settings/: smartrf_settings.c
